** sch_path: HBT_AMP2/design_data/xschem/chip/OTA33.sch
**.subckt OTA33 in VSS VDD sink ip op C1 C2 C3
*.ipin in
*.iopin VSS
*.iopin VDD
*.iopin sink
*.ipin ip
*.opin op
*.iopin C1
*.iopin C2
*.iopin C3
XM1 net10 net18 net2 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {12*$pw}]] l=[string map {{$} {}} [ev
+ {2*$pl}]] ng=5 m=2
XM2 net9 net17 net2 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {12*$pw}]] l=[string map {{$} {}} [ev
+ {2*$pl}]] ng=5 m=2
Vmeas3 VDD net4 0
.save i(vmeas3)
XM3 net10 net10 net1 VSS sg13_hv_nmos w=[string map {{$} {}} [ev {$nw}]] l=[string map {{$} {}} [ev {$nl}]]
+ ng=1 m=1
XM4 net7 net10 net3 VSS sg13_hv_nmos w=[string map {{$} {}} [ev {2*$nw}]] l=[string map {{$} {}} [ev
+ {$nl}]] ng=2 m=1
Vmeas8 net3 VSS 0
.save i(vmeas8)
Vmeas9 net1 VSS 0
.save i(vmeas9)
XM5 net8 V++ net4 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {4*$pw}]] l=[string map {{$} {}} [ev {$pl}]]
+ ng=2 m=1
XM6 net2 V+ net8 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {4*$pw}]] l=[string map {{$} {}} [ev {$pl}]]
+ ng=2 m=1
XM7 net16 net9 net6 VSS sg13_hv_nmos w=[string map {{$} {}} [ev {2*$nw}]] l=[string map {{$} {}} [ev
+ {$nl}]] ng=2 m=1
XM8 net9 net9 net5 VSS sg13_hv_nmos w=[string map {{$} {}} [ev {$nw}]] l=[string map {{$} {}} [ev {$nl}]]
+ ng=1 m=1
Vmeas10 net5 VSS 0
.save i(vmeas10)
Vmeas11 net6 VSS 0
.save i(vmeas11)
XM9 net7 net17 net2 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {12*$pw}]] l=[string map {{$} {}} [ev
+ {2*$pl}]] ng=5 m=2
XM10 net16 net18 net2 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {12*$pw}]] l=[string map {{$} {}} [ev
+ {2*$pl}]] ng=5 m=2
Vmeas2 VDD net11 0
.save i(vmeas2)
XM11 net14 net15 net11 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {$pw}]] l=[string map {{$} {}} [ev
+ {$pl}]] ng=1 m=1
XM12 op V+ net14 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {$pw}]] l=[string map {{$} {}} [ev {$pl}]]
+ ng=1 m=1
XM13 op V- net7 VSS sg13_hv_nmos w=[string map {{$} {}} [ev7 {15.975*$nw}]] l=[string map {{$} {}} [ev
+ {$nl}]] ng=9 m=1
Vmeas5 VDD net12 0
.save i(vmeas5)
XM14 net13 net15 net12 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {$pw}]] l=[string map {{$} {}} [ev
+ {$pl}]] ng=1 m=1
XM15 net15 V+ net13 VDD sg13_hv_pmos w=[string map {{$} {}} [ev {$pw}]] l=[string map {{$} {}} [ev {$pl}]]
+ ng=1 m=1
XM16 net15 V- net16 VSS sg13_hv_nmos w=[string map {{$} {}} [ev7 {15.975*$nw}]] l=[string map {{$} {}}
+ [ev {$nl}]] ng=9 m=1
x12 net19 sink V++ V+ V- V-- net20 OTA33_BiAS nw=[string map {{$} {}} [ev {$nw}]] nl=[string map {{$} {}}
+ [ev {$nl}]] pw=[string map {{$} {}} [ev {$pw}]] pl=[string map {{$} {}} [ev {$pl}]]
Vmeas1 net20 VSS 0
.save i(vmeas1)
Vmeas4 VDD net19 0
.save i(vmeas4)
R14 ip net18 1 m=1
R11 net17 in 1 m=1
XC2 C3 VSS cap_cmim w=9.0e-6 l=30.0e-6 m=1 mm_ok=1
XC3 C2 VSS cap_cmim w=9.0e-6 l=30.0e-6 m=1 mm_ok=1
XC4 C1 VSS cap_cmim w=9.0e-6 l=30.0e-6 m=1 mm_ok=1
**** begin user architecture code






**** end user architecture code
**.ends
.end
